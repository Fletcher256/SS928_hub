# Keil uVision project LED_1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\LIBS;.\START;.\USER;.\Core;.\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIBS
    ./LIBS/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group START
    ./START/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s core_cm3.h stm32f10x.h system_stm32f10x.h
  group USER
    ./USER/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
    ./: main.c
    ./HARDWARE/: CarApp.c
    ./Core/: CarApp.h CarControl.h CarControl.c CarProtocol.c CarProtocol.h CommandParser.c CommandParser.h HeadingControl.c HeadingControl.h
  group SYSTEM
    ./Core/: Timers.c Timers.h
  group HARDWARE
    ./HARDWARE/: Keys.c Keys.h key.c key.h PWMO.c USART.c USART.h Motors.c Motors.h _MyI2C_.c filter.c generic.c LED.c LED.h YH8.c YH8.h
